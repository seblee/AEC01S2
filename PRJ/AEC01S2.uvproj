# Keil uVision project AEC01S2.uvproj, settings and files
target AEC01S2 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: AEC01S2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\USER;..\APP\inc;..\LIB\inc
  link misc: REMOVEUNUSED
  group USER
    ../USER/: Main.c System_init.c Task.c
  group APP
    ../APP/src/: APP.c APP_Lamp.c APP_WDT.c APP_PCA_PWM.c APP_AHT21.c
  group ISR
    ../LIB/isr/: STC8G_H_GPIO_Isr.c STC8G_H_Timer_Isr.c STC8G_H_UART_Isr.c STC8G_PCA_Isr.c
  group LIB
    ../LIB/src/: STC8G_H_Delay.c STC8G_H_GPIO.c STC8G_H_Timer.c STC8G_H_UART.c STC8G_PCA.c STC8G_H_Soft_I2C.c STC8G_H_WDT.c STC8G_H_NVIC.c STC8G_H_ADC.c STC8G_H_Compare.c STC8G_H_I2C.c STC8G_H_SPI.c STC8G_H_Exti.c
